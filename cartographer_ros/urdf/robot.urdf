Commit message: Update robot.urdf

File: cartographer_ros/urdf/robot.urdf (robot description, URDF)
Before this commit: robot test_robot, 3 links, 2 joints
Joints:
- joint joint1: origin xyz=0.0 0.0 0.0415 rpy=0.0 0.0 -1.571  -> xyz=0.0 0.0 0.0415 rpy=3.1415 0.0 1.571 
